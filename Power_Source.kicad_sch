File: Power_Source.kicad_sch (KiCad schematic)
At the start: 4 parts

Commit message: data refresh
Other:
- note removed: "Borne 2EDGRC-5,0 Macho 5P 90º"
- note removed: "borne-2edgk-5-0-femea-5p"
